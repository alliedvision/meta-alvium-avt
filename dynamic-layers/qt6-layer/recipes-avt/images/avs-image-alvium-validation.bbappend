TOOLCHAIN_HOST_TASK:append = " nativesdk-packagegroup-qt6-toolchain-host "