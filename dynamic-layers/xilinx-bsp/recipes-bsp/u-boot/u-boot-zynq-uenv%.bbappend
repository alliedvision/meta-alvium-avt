do_compile[depends] += " device-tree:do_deploy "