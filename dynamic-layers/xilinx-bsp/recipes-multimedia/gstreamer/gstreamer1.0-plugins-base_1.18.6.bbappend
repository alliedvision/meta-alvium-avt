RDEPENDS_libgstgl-1.0 = " libmali-xlnx"
PACKAGE_ARCH_mali400 = "${SOC_VARIANT_ARCH}"
