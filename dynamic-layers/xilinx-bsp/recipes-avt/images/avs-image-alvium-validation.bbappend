CORE_IMAGE_EXTRA_INSTALL += " \
        libmali-xlnx \
        qsiv \
        "