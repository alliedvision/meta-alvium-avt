CORE_IMAGE_EXTRA_INSTALL += "avt-board-config"
CORE_IMAGE_EXTRA_INSTALL += "u-boot-imx-env u-boot-fw-utils"