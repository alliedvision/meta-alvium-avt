FILESEXTRAPATHS:prepend := "${THISDIR}/imx:"

SRC_URI:append:imx8mpevk = " file://0001_set_fdtfile_alvium.patch "


