
PACKAGECONFIG:remove:zynqmp = "xcomposite-egl xcomposite-glx"
